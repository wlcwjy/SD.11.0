# Keil uVision project SD.11.0.uvprojx, settings and files
target SD.11.0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MM32F0162D6PV MindMotion
  pack: MindMotion.MM32F0160_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: SD_11_0 +hex
  AfterMake: D:\Program Files\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ..\release\SD.11.0.bin Y:\KEIL\SD.11.0\SD_11_0.axf
  AfterMake: F:\SynologyDrive\svn\QT\ChangeVersion\release\ChangeVersion.exe ../source/app/system.h ../release/SD.11.0.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Source\app;..\Source\driver;..\..\..\..\Common\MM32F0160_V1.2.3\Device\MM32F0160\HAL_lib\inc;..\..\..\..\Common\MM32F0160_V1.2.3\Device\MM32F0160\Include;..\..\..\..\Common\MM32F0160_V1.2.3\Device\CMSIS\KEIL_CORE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1f000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group app
    ../Source/app/: main.c crontab.c
  group driver
    ../Source/driver/: board.c delay.c voice.c table.c flash.c trace.c led.c led_animation.c aip33620.c slow_action.c
  group lib
    ../../../../Common/MM32F0160_V1.2.3/Device/Project/release/: mm32f0160.lib
  group startup
    ../../../../Common/MM32F0160_V1.2.3/Device/MM32F0160/Source/: system_mm32f0160.c
    ../../../../Common/MM32F0160_V1.2.3/Device/MM32F0160/Source/KEIL_StartAsm/: startup_mm32f0160_keil.s
